# Keil uVision project cdc_acm.uvproj, settings and files
target USBFS_DCDC (ARM-ADS)
  device: GD32F350G8 GigaDevice
  cpu: IRAM(0x20000000-0x20001FFF)IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: USBD_CDC_ACM +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F350
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\Utilities;..\..\..\..\..\..\GD32F3x0_Firmware_Library\CMSIS\GD\GD32F3x0\Include;..\..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_standard_peripheral\Include;..\..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_driver\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../src/: app.c cdc_acm_core.c gd32f3x0_it.c usb_delay.c
  group CMSIS
    ../../../../../../GD32F3x0_Firmware_Library/GD32F3x0_usbfs_driver/Source/: system_gd32f3x0.c
  group GD32F350G_START
    ../../../../../Utilities/: gd32f350g_start.c
  group GD32F3x0_StdPeriph_Driver
    ../../../../../../GD32F3x0_Firmware_Library/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group Startup
    ../../../../../../GD32F3x0_Firmware_Library/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group USB_Driver
    ../../../../../../GD32F3x0_Firmware_Library/GD32F3x0_usbfs_driver/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
  group Doc
    ../: readme.txt
