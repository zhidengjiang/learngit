# Keil uVision project HID_keyborad.uvproj, settings and files
target USB_DHID(USBFS) (ARM-ADS)
  device: GD32F350RB GigaDevice
  cpu: IRAM(0x20000000-0x20003FFF)IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: HID_keyboard +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USBFS,GD32F350
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\GD32F3x0_Firmware_Library\CMSIS\GD\GD32F3x0\Include;..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_standard_peripheral\Include;..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_driver\Include;..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../src/: gd32f3x0_it.c hid_core.c main.c usb_delay.c
  group CMSIS
    ../../../../../GD32F3x0_Firmware_Library/GD32F3x0_usbfs_driver/Source/: system_gd32f3x0.c
  group GD32F3x0_StdPeriph_Driver
    ../../../../../GD32F3x0_Firmware_Library/GD32F3x0_standard_peripheral/Source/: gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_gpio.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_usart.c
  group GD32F3x0_EVAL
    ../../../../Utilities/: gd32f350r_eval.c
  group Startup
    ../../../../../GD32F3x0_Firmware_Library/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group USB_Driver
    ../../../../../GD32F3x0_Firmware_Library/GD32F3x0_usbfs_driver/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
  group Doc
    ../: readme.txt
