# Keil uVision project USBH_HID.uvproj, settings and files
target USBFS_HID_HOST (ARM-ADS)
  device: GD32F350RB GigaDevice
  cpu: IRAM(0x20000000-0x20003FFF)IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: USBH-HID +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USBFS,GD32F350
  c include: ..\inc;..\..\..\..\..\GD32F3x0_Firmware_Library\CMSIS\GD\GD32F3x0\Include;..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_standard_peripheral\Include;..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_driver\Include;..\..\..\..\Utilities;..\..\..\..\Utilities\LCD_Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../src/: gd32f3x0_it.c main.c usb_delay.c usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_usr.c systick.c
  group CMSIS
    ../../../../../GD32F3x0_Firmware_Library/GD32F3x0_usbfs_driver/Source/: system_gd32f3x0.c
  group GD32F3x0_Peripherals
    ../../../../../GD32F3x0_Firmware_Library/GD32F3x0_standard_peripheral/Source/: gd32f3x0_exti.c gd32f3x0_gpio.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_usart.c
  group GD32F350R_EVAL
    ../../../../Utilities/: gd32f3x0_lcd_eval.c gd32f350r_eval.c
    ../../../../Utilities/LCD_Common/: lcd_log.c
  group USB_Driver
    ../../../../../GD32F3x0_Firmware_Library/GD32F3x0_usbfs_driver/Source/: usb_core.c usbh_core.c usbh_ctrl.c usbh_hcs.c usbh_int.c usbh_std.c
  group Startup
    ../../../../../GD32F3x0_Firmware_Library/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group Doc
    ../: readme.txt
